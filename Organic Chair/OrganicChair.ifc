Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-01-31T16:34:33
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 31 16:34:33 2019 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{0751FC00-BDF3-449F-8A11-600F51C0FFEF}\ifc * Database version: 5507 * Database creation date: Thu Jan 31 16:34:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 31 16:34:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 31 16:34:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Organic Chair - Natural Oak, CONV_Vitra_DmstcChrs_OrganicChair:Organic Chair - Natural Oak:336387
In: Level 1
Material: Textile hopsak blue moor, Glide black, Natural Oak
Pset_ManufacturerTypeInformation - ModelReference: 21001000; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.64437 m2; Volume: 0.403734 m3
Materials and Finishes - ChairMainMaterial: Textile hopsak blue moor
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Furniture; Family: CONV_Vitra_DmstcChrs_OrganicChair: Organic Chair - Natural Oak; Family and Type: CONV_Vitra_DmstcChrs_OrganicChair: Organic Chair - Natural Oak; InstallationDate: n/a; Material: Wood, textile & polyurethane; SerialNumber: n/a; TagNumber: n/a; Type: CONV_Vitra_DmstcChrs_OrganicChair: Organic Chair - Natural Oak; Type Id: CONV_Vitra_DmstcChrs_OrganicChair: Organic Chair - Natural Oak; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
General(Type) - Author: Convergo AB; BIMObjectName: CONV_Vitra_DmstcChrs_OrganicChair; ConvergoRefNr: 0089-1812-0131-CH; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: The Organic Chair – a small and comfortable reading chair – was developed in several versions for the ‘Organic Design in Home Furnishings’ competition organized by the Museum of Modern Art in New York. With its sculptural shapes, the design was ahead of the times. But due to the absence of suitable manufacturing techniques, the armchair never went into production. Not until did it become possible to manufacture and market organically shaped seat shells in large quantities, as exemplified by Charles and Ray Eames‘s famous Plastic Armchair or Saarinen‘s Tulip Chair.; Revision: n/a; Uniclass2: Pr_40_50_12_48; Uniclass2015Description: Easy chairs; Uniclass2015Reference: Pr_40_50_12_26; Version: 1; VersionDate: 17/01/2019
Identity Data(Type) - Collection: Organic Chair; Cost: 0; Description: The Organic Chair – a small and comfortable reading chair – was developed in several versions for the ‘Organic Design in Home Furnishings’ competition organized by the Museum of Modern Art in New York. With its sculptural shapes, the design was ahead of the times. But due to the absence of suitable manufacturing techniques, the armchair never went into production. Not until did it become possible to manufacture and market organically shaped seat shells in large quantities, as exemplified by Charles and Ray Eames‘s famous Plastic Armchair or Saarinen‘s Tulip Chair.; Designer: Charles Eames & Eero Saarinen; Manufacturer: Vitra; Model: Organic Chair - Natural Oak; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; ProductDatasheet: https://www.vitra.com/en-un/_storage/asset/191098/storage/master/download/FS_Organic_Chair-EN_Preview-Single-Page.pdf; Type Name: Organic Chair - Natural Oak; URL: https://www.vitra.com/en-un/product/organic-chair
Materials and Finishes(Type) - ChairSecondaryMaterial: Natural Oak; ChairTertiaryMaterial: Glide black
Other(Type) - AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; Category: Chairs; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: CONV_Vitra_DmstcChrs_OrganicChair; Features: n/a; Finish: n/a; Grade: n/a; ModelNumber: n/a; ModelReference: 21001000; Name: DmstcChrs_OrganicChair; ReplacementCost: n/a; Shape: Sculptured; Size: 725x675x825 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
